# Keil uVision project F4Project.uvprojx, settings and files
target F405RG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\APP;..\BSP;..\FatFs;..\LIB\STM32F4xx_StdPeriph_Driver\inc;..\LIB\CMSIS\Include;..\LIB\CMSIS\STM32F4xx\Include;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c
  group FatFs
    ../FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group BSP
    ../BSP/: delay.c sys.c led.c spi.c sdcard.c
  group LIB
    ../LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c
  group CMSIS
    ../LIB/CMSIS/STM32F4xx/: system_stm32f4xx.c
    ../LIB/CMSIS/STM32F4xx/arm/: startup_stm32f40_41xxx.s
  group Changelog
    ../../: changelog.txt
